# Repository tompi/Ferris-Sweep-Tweaked

File README.md:

A custom version of the Ferris Sweep. 
 https://github.com/davidphilipbarr/Sweep
 
 This verison has a tightenend up edge cut.  See Ben Vallack's video for how to customise these. 
 https://youtu.be/JqpBKuEVinw
 
 Components used with price(I ordered for 2 keyboards):
 
 |Component|#|Total amount including shipping & VAT|
 | ----------- | -----------: | -----------: | 
 |[TYPE-C USB ATMEGA32U4-MU](https://www.aliexpress.com/item/32840365436.html)|4|$ 28.55|
 |[TRRS 3.5 MM Audio Jack Connector](https://www.aliexpress.com/item/33029465106.html)|10|$ 3.06|
 |[Kailh Choc Red Crystal Switch](https://www.aliexpress.com/item/4001016150022.html)|70|$ 64.13|
 |[Kailh Black Low Profile Keycaps](https://www.aliexpress.com/item/32979973961.html)|60|$ 19.99|
 |[PCB print]()|5|$ 11.90|
 ||||
 ||||
 ||||
 ||||

## KiCad design ferris-sweep-compact.kicad_pcb

Board: 2 copper layers, 109.2 x 87.5 mm, 20 parts (2 on the bottom side), 21 nets.

Parts:
J1: MJ-4PP-9
RSW1: Val**; ResetSW
SW2, SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW20, SW21: SW_PUSH; SW_PG1350_reversible_b2
U1: ProMicro; ProMicro_v3

Connections:
GND: J1.C, RSW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW20.2, SW21.2, U1.3, U1.4, U1.23
LED: SW12.1, U1.1
unnamed: SW20.1, U1.11
unnamed: SW21.1, U1.12
unnamed: SW11.1, U1.13
unnamed: SW10.1, U1.14
SCL: SW15.1, U1.6
SDA: SW14.1, U1.5
VCC: J1.D, U1.21
col0: SW6.1, U1.20
col1: SW5.1, U1.19
col2: SW4.1, U1.18
col3: SW3.1, U1.17
col4: SW8.1, U1.16
col5: SW9.1, U1.15
data: J1.B, U1.2
reset: RSW1.1, U1.22
row0: SW16.1, U1.7
row1: SW17.1, U1.8
row2: SW18.1, U1.9
row3: SW2.1, U1.10

## Commit log

2022-01-05 Updated edge cuts
2022-01-06 Added text layer and finished edge cuts
2022-02-09 BOM update and tweaks on PCB
2022-02-10 Update gerber
2022-02-10 Gerber update
